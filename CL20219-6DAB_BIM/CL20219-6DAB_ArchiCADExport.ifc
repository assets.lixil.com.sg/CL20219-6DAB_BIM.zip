Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-02-22T19:11:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Feb 22 19:11:23 2025 * Host: DESKTOP-EKL9I0B * Database: C:\Users\WINDOW~1\AppData\Local\Temp\b4f786ae-b724-4c26-b1e6-41a402ad0c2b\90429eac-bd65-4482-8471-2450d0abe8b4\ifc * Database version: 5507 * Database creation date: Sat Feb 22 19:11:22 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Feb 22 19:11:22 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Feb 22 19:11:22 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: Sanitary_Toilets_American Standard_Plat 46l Smart Toilet (Auto Seat And Music Function):CL20219-6DAB-PLAT 4/6L Shower Toilet(Auto Seat+Music), Sanitary_Toilets_American Standard_Plat 46l Smart Toilet (Auto Seat And Music Function):CL20219-6DAB-PLAT 4/6L Shower Toilet(Auto Seat+Music):350064
In: Level 1
Type - Material: American Standard - Polypropylene - White
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: CL20219-6DAB-PLAT 4/6L Shower Toilet(Auto Seat+Music)
Material: American Standard - Polypropylene - White, American Standard - Plastic
Pset_DistributionFlowElementCommon - Reference: CL20219-6DAB-PLAT 4/6L Shower Toilet(Auto Seat+Music); sets with these values: 2
